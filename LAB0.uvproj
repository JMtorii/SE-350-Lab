# Keil uVision project LAB0.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: Cortex-M3 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M3") ESEL ELITTLE
  output: LAB0
  c flags: Optim=1
  group Source Group 1
    ./: startup_LPC17xx.s system_LPC17xx.c
